# Keil uVision project DEOD_stm32f407DM(sil2).uvprojx, settings and files
target DEOD_stm32f407DM(sil2) (6230000::V6.23::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DEOD_stm32f407vgtDM +hex
  AfterMake: C:\Users\USER\AppData\Local\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin --output=$P\Binary\@P.bin #L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F407xx
  c include: .\Sources;.\Sources\Applications;.\common\drivers;.\common\libraries;.\STM32_Safety_STL\Inc;.\STM32_Safety_STL\Lib
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./Sources/Applications/: main.c device.c stm32f4xx_it.c self_diagnose_perform.c console_thread.c sysmon_thread.c deod_thread.c stl.c
  group STL_Lib
    ./STM32_Safety_STL/Src/: stl_user_param_template.c stl_util.c
    ./STM32_Safety_STL/Lib/: STL_Lib.a
  group Drivver
    ./common/drivers/: led.c rs232.c watchdog.c digital_output.c digital_input.c relay.c periph_stm32f4xx.c tpm117.c dip_switch.c
  group Libraries
    ./common/libraries/: lib_buffer.c lib_string.c lib_command.c
software components: CMSIS:CORE 5.6.0, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:ADC 1.7.9, Device:STM32Cube HAL:CRC 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:Flash 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:I2C 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:UART 1.7.9, Device:STM32Cube HAL:USART 1.7.9, Device:Startup 2.6.3
